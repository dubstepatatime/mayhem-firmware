options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/foo.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Porpack_Capture.C16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ' 1.0 / 32768.0'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
